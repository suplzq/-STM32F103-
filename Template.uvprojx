# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\App\ENCODER;.\App\MOTOR;.\App\LED;.\App\CONTROL;.\App\color;.\App\STEER;.\App\OLED;.\App\show;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\App\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c misc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_spi.c stm32f10x_exti.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group Public
    ./Public/: system.c SysTick.c 5ms_pulse.c usart.c
  group App
    ./App/MOTOR/: motor.c
    ./App/ENCODER/: encoder.c
    ./App/CONTROL/: control.c
    ./App/color/: color.c
    ./App/STEER/: steer.c
    ./App/OLED/: oled.c
    ./App/show/: show.c
    ./App/EXTI/: exti.c
